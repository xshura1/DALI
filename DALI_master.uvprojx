# Keil uVision project DALI_master.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DALI_master
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c config.h timers.c timers.h uart.c uart.h dali.h dali.c spi.c spi.h dali_config.h dali_cmd.h dali_cmd.c utils.h utils.c cmd.c cmd.h cmd_token.h cmd_func.c cmd_func.h cmd_msg.h irq_handlers.c socket.c socket.h w5500.c w5500.h wizchip_conf.c wizchip_conf.h tcp.c tcp.h i2c.c i2c.h rtc.c rtc.h
software components: CMSIS:CORE 5.2.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
